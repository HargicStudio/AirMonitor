# IAR project Backup (2) of Project.ewp, settings and files
configuration STM324xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Inc; ..\..\User; ..\..\Platform\glo_def; ..\..\Platform\AaShell; ..\..\Platform\AaMem; ..\..\Platform\AaSysLog; ..\..\Platform\AaTag; ..\..\Platform\AaThread; ..\..\Platform\CCSDaemon; ..\..\Common\BipBuffer; ..\..\Common\RingBuffer; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\BSP\407VE; ..\..\Middlewares\Third_Party\FatFs\src; ..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\User\common; ..\..\Common\PingPangBuffer
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: AirMonitor.bin
  ILINK.IlinkOutputFile: AirMonitor.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group AaPlatform
    ../../Platform/AaMem/: AaMem.c
    ../../Platform/AaShell/: AaShell.c
    ../../Platform/AaSysLog/: AaSysLogInterface.c AaSysLogSystem.c
    ../../Platform/AaTag/: AaTag.c
    ../../Platform/AaThread/: AaThread.c
    ../../Platform/CCSDaemon/: CCSDaemon.c
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c
  group Common
    ../../Common/BipBuffer/: BipBuffer.c
    ../../Common/PingPangBuffer/: PingPang.c
    ../../Common/RingBuffer/: RingBufferUtils.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../Drivers/BSP/407VE/: 407VE_sd.c ads1222.c cp15_dev.c gps_dev.c gsm_dev.c gsm_power_dev.c led_dev.c print_com.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group User
    ../../User/: alpha_sense.c am2302.c cp15.c dataRecord.c fan.c gps.c gpsAnalyser.c gsm.c gsmCtrl.c led.c osa_file.c
  group User/common
    ../../User/common/: Cfg.c common.c config.c crc.c dataHandler.c dataRecv.c format.c moduleStatus.c
