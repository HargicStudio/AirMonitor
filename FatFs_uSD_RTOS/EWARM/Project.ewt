<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM324xG_EVAL</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>AaPlatform</name>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\..\Platform\Common\BipBuffer\BipBuffer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Platform\Common\RingBuffer\RingBufferUtils.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\Platform\AaMem\AaMem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Platform\AaShell\AaShell.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Platform\AaSysCom\AaSysCom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Platform\AaSysLog\AaSysLogInterface.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Platform\AaSysLog\AaSysLogSystem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Platform\AaTag\AaTag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Platform\AaThread\AaThread.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Platform\CCSDaemon\CCSDaemon.c</name>
    </file>
  </group>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\startup_stm32f407xx.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <file>
        <name>$PROJ_DIR$\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_it.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Doc</name>
    <file>
      <name>$PROJ_DIR$\..\readme.txt</name>
    </file>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>BSP</name>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\407VE_sd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\ads1222.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\cp15_dev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\dnc3_dev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\gps_dev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\gsm_dev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\gsm_power_dev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\led_dev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\print_com.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\rtc_dev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\BSP\407VE\stm32f4xx_hal_msp.c</name>
      </file>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Src\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_sd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_wwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_sdmmc.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Middlewares</name>
    <group>
      <name>FatFs</name>
      <group>
        <name>Core</name>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FatFs\src\diskio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FatFs\src\ff.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FatFs\src\ff_gen_drv.c</name>
        </file>
      </group>
      <group>
        <name>Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FatFs\src\drivers\sd_diskio.c</name>
        </file>
      </group>
      <group>
        <name>Options</name>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FatFs\src\option\syscall.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FatFs\src\option\unicode.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>FreeRTOS</name>
      <group>
        <name>CMSIS_RTOS</name>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS\cmsis_os.c</name>
        </file>
      </group>
      <group>
        <name>portable</name>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang\heap_4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\port.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\portasm.s</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FreeRTOS\Source\croutine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FreeRTOS\Source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FreeRTOS\Source\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FreeRTOS\Source\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\FreeRTOS\Source\timers.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\..\..\User\common\Cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\common\common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\common\config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\common\crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\common\dataHandler.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\common\dataRecv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\common\format.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\common\moduleStatus.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\User\alpha_sense.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\am2302.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\cp15.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\dataRecord.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\dn7c3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\fan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\gps.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\gpsAnalyser.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\gsm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\gsmCtrl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\osa_file.c</name>
    </file>
  </group>
</project>


